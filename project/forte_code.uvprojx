# Keil uVision project forte_code.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: forte_code
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,FORTE_COMPILATION,FORTE_ENABLE_GENERATED_SOURCE_CPP,FORTE_LITTLE_ENDIAN,FORTE_SUPPORT_ARRAYS,FORTE_SUPPORT_BOOT_FILE,FORTE_SUPPORT_CUSTOM_SERIALIZABLE_DATATYPES,FORTE_SUPPORT_MONITORING,FORTE_SUPPORT_QUERY_CMD,FORTE_UNICODE_SUPPORT,FORTE_USE_64BIT_DATATYPES,FORTE_USE_LREAL_DATATYPE,FORTE_USE_REAL_DATATYPE,FORTE_USE_WSTRING_DATATYPE,LOGDEBUG,nullptr=0
  c include: ..\User;..\Drivers;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\CMSIS\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\lwip\src\include;..\lwip\src\include\lwip;..\lwip\arch;..\lwip\lwip_app;..\lwip;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\lwip\lwip_app\token;..\lwip\src\include\lwip;..\Drivers\BSP\USART6;..\Drivers\BSP\ADC;..\Drivers\BSP\FLASH_SPI;..\Drivers\BSP\NORFLASH;..\Drivers\BSP\ATK_MW1278D;..\modbus;..\Drivers\BSP\RTC;..\MALLOC;..\MD5;..\Drivers\BSP\WDG;..\Drivers\BSP\TIMER;..\cm_backtrace;..\cm_backtrace\fault_handler\keil;..\src\arch\freeRTOS;..\src\arch;..\src\core;..\src\core\cominfra;..\src\core\datatypes;..\src\core\datatypes\convert;..\src\core\utils;..\src\stdfblib;..\src\stdfblib\events;..\src\stdfblib\ita;..\src\stdfblib\net;..\src;..\src_gen;..\Middlewares;..\src\arch\be_m1;..\src\stdfblib\io
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group freertos
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos_port
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group lwip_api
    ../lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip_core
    ../lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip_netif
    ../lwip/src/netif/: ethernet.c
  group lwip_arch
    ../lwip/arch/: ethernetif.c lwip_comm.c sys_arch.c
  group lwip_app
    ../lwip/lwip_app/: hmac_sha1.c sha1.c
    ../lwip/src/apps/mqtt/: mqtt.c
  group forte_src_arch
    ../src/arch/freeRTOS/: forte_architecture.cpp forte_architecture_time.cpp forte_Init.cpp forte_sem.cpp forte_sync.cpp forte_thread.cpp freertostiha.cpp
    ../src/arch/: bsdsocketinterf.cpp devlog.cpp genforte_printer.cpp genforte_realFunctions.cpp timerha.cpp fdselecthand.cpp
    ../src/arch/utils/: mainparam_utils.cpp
  group forte_src_core
    ../src/core/cominfra/: basecommfb.cpp comlayer.cpp commfb.cpp fbdkasn1layer.cpp ipcomlayer.cpp localcomlayer.cpp rawdatacomlayer.cpp
    ../src/core/datatypes/: forte_any.cpp forte_any_bit.cpp forte_any_date.cpp forte_any_elementary.cpp forte_any_int.cpp forte_any_magnitude.cpp forte_any_num.cpp forte_any_real.cpp forte_any_string.cpp forte_array.cpp forte_bool.cpp forte_byte.cpp forte_date.cpp forte_date_and_time.cpp forte_dint.cpp forte_dword.cpp forte_int.cpp forte_lint.cpp forte_lreal.cpp forte_lword.cpp forte_real.cpp forte_sint.cpp forte_string.cpp forte_struct.cpp forte_time.cpp forte_time_of_day.cpp forte_udint.cpp forte_uint.cpp forte_ulint.cpp forte_usint.cpp forte_word.cpp forte_wstring.cpp unicode_utils.cpp
    ../src/core/utils/: configFileParser.cpp parameterParser.cpp string_utils.cpp
    ../src/core/: adapter.cpp adapterconn.cpp anyadapter.cpp basicfb.cpp cfb.cpp conn.cpp dataconn.cpp devexec.cpp device.cpp ecet.cpp ecetFactory.cpp eventconn.cpp extevhan.cpp fbcontainer.cpp funcbloc.cpp iec61131_functions.cpp if2indco.cpp monitoring.cpp resource.cpp simplefb.cpp stringdict.cpp typelib.cpp
  group forte_src_stdfb
    ../src/stdfblib/: timedfb.cpp
    ../src/stdfblib/events/: ARTimeOut.cpp ATimeOut.cpp E_CTD.cpp E_CTU.cpp E_CTUD.cpp E_CYCLE.cpp E_D_FF.cpp E_DELAY.cpp E_DEMUX.cpp E_F_TRIG.cpp E_MERGE.cpp E_PERMIT.cpp E_R_TRIG.cpp E_RDELAY.cpp E_REND.cpp E_RESTART.cpp E_RS.cpp E_RTimeOut.cpp E_SELECT.cpp E_SPLIT.cpp E_SR.cpp E_SWITCH.cpp E_T_FF.cpp E_TimeOut.cpp E_TRAIN.cpp GEN_E_DEMUX.cpp GEN_E_MUX.cpp
    ../src/stdfblib/ita/: DEV_MGR.cpp EMB_RES.cpp ForteBootFileLoader.cpp RMT_DEV.cpp RMT_RES.cpp
    ../src/stdfblib/net/: GEN_CLIENT.cpp GEN_PUBL.cpp GEN_PUBLISH.cpp GEN_SERVER.cpp GEN_SUBL.cpp GEN_SUBSCRIBE.cpp
  group forte_src
    ../src/: forteinit.cpp stringlist.cpp
  group forte_core
    ../core/: deviceExecutionHandlers.cpp
    ../core/cominfra/: comlayersmanager.cpp
  group Middlewares
    ../Middlewares/MALLOC/: malloc.c
  group Driver/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_rcc.c
  group Driver/BSP
    ../Drivers/BSP/ETHERNET/: ethernet.c
    ../Drivers/BSP/KEY/: key.c
    ../Drivers/BSP/LED/: led.c
    ../Drivers/BSP/RTC/: rtc.c
    ../Drivers/BSP/TIMER/: btim.c
    ../Drivers/BSP/USART6/: usart6.c
    ../Drivers/BSP/WDG/: wdg.c
  group Driver/SYSTEM
    ../Drivers/SYSTEM/delay/: delay.c
    ../Drivers/SYSTEM/sys/: sys.c
    ../Drivers/SYSTEM/usart/: usart.c
  group user
    ../User/: forte_main.cpp freertos_task.c main.c stm32f4xx_it.c
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
